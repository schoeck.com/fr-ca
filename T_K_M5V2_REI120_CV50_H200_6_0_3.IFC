Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-01-12T15:02:00
Written by: IfcOpenShell 0.5.0-dev
Made in: IfcOpenShell 0.5.0-dev

# IfcBuildingElementProxy, T-K-M5V2-REI120-CV50-H200-6.0
Description: T-K-M5V2-REI120-CV50-H200-6.0
Pset_ManufacturerTypeInformation - Bestellnummer: 1158029; Beschreibung: \X2\00490073006F006B006F0072006200AE00200054002000740079007000650020004B002D004D0035002D00560032002D005200450049003100320030002D0043005600350030002D005800380030002D0048003200300030002D0036002E0030\X0\; Hersteller: \X2\00530063006800F60063006B0020004200610075007400650069006C006500200047006D00620048\X0\; Datei: T-K-M5V2-REI120-CV50-H200-6.0; EAN: 4056327485897; Name: \X2\00490073006F006B006F0072006200AE00200054002000740079007000650020004B002D004D0035002D00560032002D005200450049003100320030002D0043005600350030002D005800380030002D0048003200300030002D0036002E0030\X0\
