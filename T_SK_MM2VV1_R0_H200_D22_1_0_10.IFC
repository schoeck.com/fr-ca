Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-01-12T15:08:02
Written by: IfcOpenShell 0.5.0-dev
Made in: IfcOpenShell 0.5.0-dev

# IfcBuildingElementProxy, T-SK-MM2VV1-R0-H200-D22-1.0
Description: T-SK-MM2VV1-R0-H200-D22-1.0
Pset_ManufacturerTypeInformation - Bestellnummer: 1027110; Beschreibung: \X2\00490073006F006B006F0072006200AE002000540020007400790070006500200053004B002D004D004D0032002D005600560031002D00520030002D005800380030002D0048003200300030002D004C003100380030002D004400320032002D0031002E0030\X0\; Hersteller: \X2\00530063006800F60063006B0020004200610075007400650069006C006500200047006D00620048\X0\; Datei: T-SK-MM2VV1-R0-H200-D22-1.0; EAN: 4024342282425; Name: \X2\00490073006F006B006F0072006200AE002000540020007400790070006500200053004B002D004D004D0032002D005600560031002D00520030002D005800380030002D0048003200300030002D004C003100380030002D004400320032002D0031002E0030\X0\
